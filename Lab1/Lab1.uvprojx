# Keil uVision project Lab1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab1 +hex
  AfterMake: @KARM\ARMCC\bin\fromelf.exe --bin $L@L.axf --output $L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: 1.c 2.c 3.c main.h blinker.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
